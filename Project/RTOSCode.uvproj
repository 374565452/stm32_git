# Keil uVision project RTOSCode.uvproj, settings and files
target RTOSCode (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FMSender +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\startup;..\Libraries\CMSIS;..\Libraries\FWLib\inc;..\User;..\Common;..\Libraries\FWLib;..\Libraries\FWLib\src;..\FreeRTOS;..\FreeRTOS\include;..\App;..\Common;..\Driver;..\HDL;..\Module;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32_eval.c stm32f10x_it.c
  group FREERTOS
    ../FreeRTOS/: list.c port.c tasks.c FreeRTOSConfig.h heap_4.c croutine.c event_groups.c queue.c timers.c
  group DRIVER
    ../Driver/: gpio.c
  group APP
    ../App/: power_ctl.c led.c startup.c
  group HDL
    ../HDL/: hdl_rcc.c hdl.c hdl_gpio.c hdl_i2c.c hdl_uart.c hdl_flash.c hdl_iwdg.c hdl_include.h hdl_wwdg.c hdl_spi.c hdl_adc.c hdl_exti.c
  group MODULE
    ../Module/: m_key.c readme.txt m_util.c m_menu.c
  group HARDWARE
    ../Hardware/: rds_encoder.c amp_ctrl.c
  group COMMON
    ../Common/: common.h
